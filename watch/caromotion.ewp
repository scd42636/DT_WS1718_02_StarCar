# IAR project caromotion.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: CC430F6137 CC430F6137
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC430
  ICC430.newCCIncludePaths: ; content\; content\firmware\; content\drivers\; content\drivers\simpliciti\; content\drivers\simpliciti\stack\; content\drivers\simpliciti\stack\bsp\; content\drivers\simpliciti\stack\bsp\drivers\; content\drivers\simpliciti\stack\bsp\boards\CC430EM\; content\drivers\simpliciti\stack\mrfi\; content\drivers\simpliciti\stack\nwk\; content\drivers\simpliciti\stack\nwk_applications\
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnkcc430f6137.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group content
    content/: defines.h program.c
  group content/drivers/simpliciti
    content/drivers/Simpliciti/: Simpliciti.c simpliciti.h
  group content/firmware
    content/firmware/: firmware.c firmware.h

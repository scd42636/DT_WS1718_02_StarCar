# IAR project Carmotion.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: CC430F6137 CC430F6137
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: ISM_EU; MRFI_CC430; __CC430F6137__
  ICC430.IExtraOptions: -f"Content\SimpliciTI\Applications\configuration\End Device\smpl_config.dat"; -f"Content\SimpliciTI\Applications\configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: ; Content\; Content\Defines\; Content\Driver\; Content\Firmware\; Content\Firmware\Components\; Content\Logic\; Content\SimpliciTI\; Content\SimpliciTI\Components\bsp; Content\SimpliciTI\Components\bsp\drivers; Content\SimpliciTI\Components\bsp\boards\CC430EM; Content\SimpliciTI\Components\mrfi; Content\SimpliciTI\Components\nwk; Content\SimpliciTI\Components\nwk_applications
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnkcc430f6137.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.newCCIncludePaths: ; Content\Include\; Content\Driver\; Content\Logic\; Content\SimpliciTI\; Content\SimpliciTI\Components\bsp; Content\SimpliciTI\Components\bsp\drivers; Content\SimpliciTI\Components\bsp\boards\CC430EM; Content\SimpliciTI\Components\mrfi; Content\SimpliciTI\Components\nwk; Content\SimpliciTI\Components\nwk_applications
  group Content
    Content/: Program.c
  group Content/Driver
    Content/Driver/: adc12.c adc12.h bm.h display.c display.h ez430_chronos_drivers.r43 rf1a.c rf1a.h
  group Content/Firmware
    Content/Firmware/: Firmware.c Firmware.h
  group Content/Firmware/Components
    Content/Firmware/Components/: Accelerator.c Accelerator.h Buzzer.c Buzzer.h MotionControl.c MotionControl.h Radio.c Radio.h Timer.c Timer.h Watch.c Watch.h
  group Content/Defines
    Content/Defines/: AcceleratorDefines.h BatteryDefines.h ButtonDefines.h Defines.h SystemDefines.h TimerDefines.h
  group Content/Logic
    Content/Logic/: rfsimpliciti.c rfsimpliciti.h
  group Content/SimpliciTI
    Content/SimpliciTI/: CC430_End_Device_868MHz.r43 simpliciti.h simpliciti_readme.txt
  group Content/SimpliciTI/Applications/application/End Device
    Content/SimpliciTI/Applications/application/End Device/: main_ED_BM.c
  group Content/SimpliciTI/Applications/configuration
    Content/SimpliciTI/Applications/configuration/: smpl_nwk_config.dat
  group Content/SimpliciTI/Applications/configuration/End Device
    Content/SimpliciTI/Applications/configuration/End Device/: smpl_config.dat
  group Content/SimpliciTI/Components/bsp
    Content/SimpliciTI/Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Content/SimpliciTI/Components/bsp/boards/CC430EM
    Content/SimpliciTI/Components/bsp/boards/CC430EM/: bsp_board.c bsp_board_defs.h bsp_button_defs.h bsp_config.h bsp_driver_defs.h bsp_drivers.c bsp_led_defs.h
  group Content/SimpliciTI/Components/bsp/boards/CC430EM/bsp_external
    Content/SimpliciTI/Components/bsp/boards/CC430EM/bsp_external/: mrfi_board_defs.h
  group Content/SimpliciTI/Components/bsp/drivers
    Content/SimpliciTI/Components/bsp/drivers/: bsp_buttons.h bsp_leds.h
  group Content/SimpliciTI/Components/bsp/drivers/code
    Content/SimpliciTI/Components/bsp/drivers/code/: bsp_buttons.c bsp_generic_buttons.h bsp_generic_leds.h bsp_leds.c
  group Content/SimpliciTI/Components/bsp/mcus
    Content/SimpliciTI/Components/bsp/mcus/: bsp_msp430_defs.h
  group Content/SimpliciTI/Components/mrfi
    Content/SimpliciTI/Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Content/SimpliciTI/Components/mrfi/radios/family5
    Content/SimpliciTI/Components/mrfi/radios/family5/: mrfi_radio.c mrfi_radio_interface.c mrfi_radio_interface.h
  group Content/SimpliciTI/Components/mrfi/smartrf/CC430
    Content/SimpliciTI/Components/mrfi/smartrf/CC430/: smartrf_CC430.h
  group Content/SimpliciTI/Components/nwk
    Content/SimpliciTI/Components/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
  group Content/SimpliciTI/Components/nwk_applications
    Content/SimpliciTI/Components/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_security.c nwk_security.h
